# Keil uVision project attitude_mcu_103.uvprojx, settings and files
target attitude_mcu_103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: attitude_mcu_103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../user;../user/attitude;../user/controller;../user/sensor;../user/bsp
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group attitude
    ../user/attitude/: INS_task.c INS_task.h MahonyAHRS.c MahonyAHRS.h
  group controller
    ../user/controller/: pid.c pid.h user_lib.c user_lib.h
  group sensor
    ../user/sensor/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h ist8310driver.c ist8310driver.h ist8310driver_middleware.c ist8310driver_middleware.h
  group bsp
    ../user/bsp/: bsp_spi.c bsp_spi.h dwt.c dwt.h
software components: CMSIS:CORE 5.5.0
